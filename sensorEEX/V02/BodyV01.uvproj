# Keil uVision project BodyV01.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: BodyT0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group Source Group 1
    ./: STARTUP.A51
    ./Source/: Main.c Timer.c Control.c UART1.c UART2.c WIFI.c eeprom.c
  group Includes
    ./Include/: Basic.h control.h Includes.h STC8.H Timer.h types.h UART3.h UART4.h UART1.h UART2.h WIFI.h eeprom.h
